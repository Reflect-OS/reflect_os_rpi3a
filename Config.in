## Config.in
```kconfig
menu "Custom Packages"
    source "$NERVES_DEFCONFIG_DIR/packages/fbv_custom/Config.in"
endmenu
```
